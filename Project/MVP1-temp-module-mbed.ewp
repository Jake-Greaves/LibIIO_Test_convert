# IAR project MVP1-temp-module-mbed.ewp, settings and files
configuration MVP1-temp-module-mbed (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM3029 AnalogDevices ADUCM3029
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\libiio; ..\libiio\libxml2; ..\libiio\libserialport; ..\inc; ..\inc\config; E:\Program Files (x86)\IAR Systems\Embedded Workbench 7.5\arm\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MVP1-temp-module-mbed.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group ADuCM3029
    ../src/dma/: adi_dma.c
    ../src/gpio/: adi_gpio.c
    ../src/pwr/: adi_pwr.c
    ../src/spi/: adi_spi.c
    ../src/uart/: adi_uart.c
    ../src/wdt/: adi_wdt.c
    ../src/: common.c startup.c system.c
  group ADuCM3029/System
    ../ADuCM3029/: pinMuxBLE.c
  group libiio
    ../libiio/: buffer.c channel.c context.c debug.h device.c iio-config.h iio-errno.h iio-lock.h iio-private.h iio.h iiod-client.c iiod-client.h lock.c scan.c serial.c utilities.c xml.c
    ../: libiio.lib
  group LibIIO_Test_convert
    ../: config_json.h main.c
  group libserialport
    ../libiio/libserialport/: libserialport.h libserialport_mbed.c
  group libxml2
    ../libiio/libxml2/: buf.c buf.h c14n.c catalog.c chvalid.c config.h debugXML.c dict.c dummy.c elfgcchack.h enc.h encoding.c entities.c error.c globals.c hash.c HTMLparser.c HTMLtree.c legacy.c libxml.h list.c nanoftp.c nanohttp.c parser.c parserInternals.c pattern.c relaxng.c save.h SAX.c SAX2.c threads.c timsort.h tree.c uri.c valid.c xinclude.c xlink.c xmlIO.c xmlmemory.c xmlmodule.c xmlreader.c xmlregexp.c xmlsave.c xmlschemas.c xmlschemastypes.c xmlstring.c xmlunicode.c xmlwriter.c xpath.c xpointer.c xzlib.c xzlib.h
  group libxml2/libxml
    libiio/libxml2/libxml/: c14n.h catalog.h chvalid.h debugXML.h dict.h DOCBparser.h encoding.h entities.h globals.h hash.h HTMLparser.h HTMLtree.h list.h nanoftp.h nanohttp.h parser.h parserInternals.h pattern.h relaxng.h SAX.h SAX2.h schemasInternals.h schematron.h threads.h tree.h uri.h valid.h xinclude.h xlink.h xmlautomata.h xmlerror.h xmlexports.h xmlIO.h xmlmemory.h xmlmodule.h xmlreader.h xmlregexp.h xmlsave.h xmlschemas.h xmlschemastypes.h xmlstring.h xmlunicode.h xmlversion.h xmlwriter.h xpath.h xpathInternals.h xpointer.h
  group picojson
    ../picojson/: picojson.h
